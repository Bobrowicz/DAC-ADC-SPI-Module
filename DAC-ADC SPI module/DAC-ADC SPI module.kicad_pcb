# Repository Bobrowicz/DAC-ADC-SPI-Module

## KiCad design DAC-ADC SPI module/DAC-ADC SPI module.kicad_pcb

Parts:
C1, C2: 2.2u; C_0805_HandSoldering
C3, C5: 0.1u; C_0805_HandSoldering
C4, C6: 10u; C_0805_HandSoldering
J1: Conn_01x04_Male; Pin_Header_Straight_1x04_Pitch2.54mm
J2: Conn_01x08_Male; Pin_Header_Straight_1x08_Pitch2.54mm
J4: Conn_01x02_Male; Pin_Header_Straight_1x02_Pitch2.54mm
R1: 50R; R_0805_HandSoldering
U1: MCP1501; SOIC-8-N
U2: MCP3204; SOIC-14_N
U3: MCP4822; SOIC-8-N

Connections:
+5V: C1.1, C3.1, C4.1, C5.1, C6.1, J2.7, U1.1, U1.3, U2.14 (Vdd), U3.1 (Vdd)
/ADC_0: J1.1, U2.1 (CH0)
/ADC_1: J1.2, U2.2 (CH1)
/ADC_2: J1.3, U2.3 (CH2)
/ADC_3: J1.4, U2.4 (CH3)
/CS_0: J2.4, U2.8 (~CS~/SHDN)
/CS_1: J2.5, U3.2 (~CS)
/DAC_A: J4.2, U3.8 (VA)
/DAC_B: J4.1, U3.6 (VB)
/MISO: J2.2, U2.10 (Dout)
/MOSI: J2.3, U2.9 (Din), U3.4 (SDI)
/SCK: J2.1, U2.11 (CLK), U3.3 (SCK)
/Vref: R1.1, U1.7, U1.8, U2.13 (Vref)
/~LDAC: J2.6, U3.5 (~LDAC)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J2.8, U1.2, U1.4, U1.5, U1.6, U2.7 (DGND), U2.12 (AGND), U3.7 (Vss)
unnamed: C2.1, R1.2

Board: 2 copper layers, 22.9 x 26.7 mm, 13 parts (3 on the bottom side), 16 nets.

## Commit log

2021-03-19 Schematic capture
2021-03-23 Schematic capture completed
2021-03-24 PCB layout complete
2021-03-24 Added top layer copper pours
2021-03-24 Silk screen edit
2021-04-09 Silk screen correction
    DAC A and DAC B silk screen labels were swapped.
2021-04-16 Page setting change
    Changed page size from A4 to US Letter.
